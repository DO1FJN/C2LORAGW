# Repository DO1FJN/C2LORAGW

File README.md:

# Codec2 Lora Gateway

**Attention:** This project is in a very early alpha state. It lacks in some basic features and in documatation.

## Overview

This opensource project 'C2LoRaGW' connects LoRa (SemTech SX126x) based radios with internet / ham-net based repeater software.
To transport speech data using low bandwidth / bitrates C2LoRaGW uses only Codec2 within the UDP-RTP datastream.

The datastream used in the internet / ham-net derives from a 2012 project 'HAMdLNK' and uses the same format like my D-Star
proof-of-concept software from this time. A demo software 'DV-RPTR-App' was already developed and is still in use (now with
localaudio using pipewire) to test the UDP link.

On UHF side I defined 10 modes using the lower bandwidth modulations of the LoRa IC: 10,15,20 and 31kHz to transmit with 100%
duty on a frequency within 70cm ham-radio band (430-440MHz in Germany). C2LoRaGW acts as a hotspot transmitting and receiving on
the same frequency half-duplex. There is an option to add a 2nd transceiver to it and build a full duplex relay base station.

Because the fact that not ready-to-use LoRa based radios exist, this project contains also audio in- and output using cheap I2S
modules plus display an simple UI on a TFT or OLED display.

More information is in the [wiki](https://github.com/DO1FJN/C2LORAGW/wiki)

### Hardware

The project is preconfigured to run on a Heltec WiFi LoRa V3 board (433-510MHz).

A ready to use 80x50mm PCB *"C2LORAGW"* containing an E22-400M30S (or M33S) and a ESP32-S3 module is available as a KiCad
project: All spare IO's are routed to a 2.54mm pin header for adding extensions. This board can be powered by an USB 2A charger
or an LiPo / LiIon 1S battery. To simplify the design this board doesn't contain a charger or power switch jet (can be added on
a separate board). This PCB is sized to fit into an Hammond or Fisher aluminum case, but also have 4 mounting holes (M3).

More information is in the [wiki](https://github.com/DO1FJN/C2LORAGW/wiki)

### Firmware

Because the project is based around the ESP32-S3 (only this µC) the firmware needs only the EspressIf IDF developing environment.
As IDE there are some options, I used Microsoft VS Code. Setup like on EspressIf documentation described. This project uses
other opensource: Codec2 for example and the SemTech sx126x driver.

## Getting Started

First: READ all available documentation (it is not much). See "documentation" folder and use the
[wiki](https://github.com/DO1FJN/C2LORAGW/wiki).

Get some compatible hardware or build some:

Get an ESP32-S3 wroom based dev-kit or similar. Connect a SX1262 or SX1268 based Lora module (equipped for UHF!) to it. There is
almost no constrains in pinning the SPI or the additional GPIO pins needed.

### Flash Precompiled Firmware

1. Download the [ESP32 flashing utility](https://github.com/cpq/esputil).
2. Download the precompiled firmware image (ZIP file with a few binary images)
3. Flash the stuff

### Get Repository

* Install VisualStudio Code, add the EspressIf toolchain + esp-idf (or just the bare EspressIf stuff)
* Clone the repository from here (code button)
* copy one of the provided sdkconfig to "sdkconfig"
* Modify the GPIO and other settings in ./components/boards/breadboard.h or create a new board definition file for your target
* Config the project...  `idf.py menuconfig` (select the proper console for your target)
* Build + flash it... `idf.py flash`

tbd

### First Connection

Run the EspressIf monitor or something similar (Putty) to see C2LORA boot. After this, it shows a command prompt. Using typed
commands to establish a wifi connection (station mode) or change C2LORA settings, hostname, callsign and so on.

### Calibration

Because of the narrow bandwidth used a frequency calibration of crystal based LoRa modules is mandatory. The frequency needs to
be within a range of +/- 2.6kHz of the target value. TCXO radio modules are much better and a calibration is not required.

Calibration requires a frequency counter or an similar device to view a carrier in the 70cm band. Start calibration using the
command line:

`c2lora cali 1`

After this command the device transmits a continuous wave (unmodulated carrier). On the terminal the actual used offset value is
shown. Measure the difference between the carrier and the target frequency and add or subtract it from the shown offset. Type
in the new calculated offset:

`c2lora offset <new value>`

After this, the carrier moves to a new position.

**Warning:** Use an antenna or an dummy load while doing this!

A rule of thumb: Cheap crystal based modules have shown an initial offset of +17kHz below the target.

If done, turn of the transmitter with:

`c2lora cali 0`

### Save C2LORA Settings

All settings (frequency, mode, txpower and offset) are saved with the command

`c2lora save`

## KiCad design kicad/C2LoraGateway.kicad_pcb

Board: 4 copper layers, 82.0 x 50.0 mm, 65 parts (2 on the bottom side), 60 nets.

Parts:
C1: 2.2p; C_0805_2012Metric
C2, C4, C5, C6, C12, C13, C14, C18: 10µ; C_1206_3216Metric
C3, C8, C9, C10, C11, C16, C17, C19: 100n; C_0603_1608Metric
C7: 3.9p; C_0805_2012Metric
C15: 220µ; C_Elec_8x6.2
D1, D5: 1608SURC; LED_0603_1608Metric
D2, D6: 1608MGC; LED_0603_1608Metric
D3: ZXRE125; SOT-23
D4: SM6T6V8A; D_SMB
FID1, FID2: Fiducial_1mm_Sqare; Fiducial_1mm_Square
H1, H2, H3, H4: MountingHole_3.2mm_M3
J1: UHF; SMA_Samtec_SMA-J-P-X-ST-EM1_EdgeMount
J2: ISP/UART0; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J3: I/O; PinHeader_2x15_P2.54mm_Vertical
J4: USB; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J5: Bat; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
JP2: VminProt; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: USB supply; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L2, L3: 2.2µ; L_Changjiang_FNR6045S
M1: E22-400M30S
R2, R14: 1M; R_0603_1608Metric
R3, R10, R17: 1.5K; R_0603_1608Metric
R4: 110K; R_1206_3216Metric
R5, R8: 100R; R_0603_1608Metric
R6: 100K; R_0603_1608Metric
R7, R11, R12: 560K; R_0603_1608Metric
R9: 2.7K; R_0603_1608Metric
R13, R15: 5.1K; R_0603_1608Metric
R16: 1.2K; R_0603_1608Metric
SW1: Boot; SW_Push_Switronic_IT1102WB8
SW2: Reset; SW_Push_Switronic_IT1102WB8
U1, U2: TPS63000; Texas_DRC0010J
U3: APX809S31SA; SOT-23
U4: D3V3XA4B10LP; Diodes_UDFN-10_1.0x2.5mm_P0.5mm
U5: TLV7011DCK; SOT-353_SC-70-5
U6: ESP32-S3-WROOM-1

Connections:
5V_ENABLE: U1.6 (EN), U6.12 (GPIO8/TOUCH8/ADC1_CH7/SUBSPICS1)
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, D2.2 (A), J3.29, M1.9 (VCC), M1.10 (VCC), R2.2, U1.1 (VOUT)
/CTS0: J3.6, U6.9 (GPIO16/U0CTS/ADC2_CH5/XTAL_32K_N)
/IO0/Boot: D5.1 (K), J2.6, SW1.1, U6.27 (GPIO0/BOOT)
/IO1: J3.28, U6.39 (GPIO1/TOUCH1/ADC1_CH0)
/IO2: J3.30, U6.38 (GPIO2/TOUCH2/ADC1_CH1)
/IO4: J3.10, U6.4 (GPIO4/TOUCH4/ADC1_CH3)
/IO5: J3.12, U6.5 (GPIO5/TOUCH5/ADC1_CH4)
/IO6: J3.14, U6.6 (GPIO6/TOUCH6/ADC1_CH5)
/IO7: J3.16, U6.7 (GPIO7/TOUCH7/ADC1_CH6)
/IO14: J3.18, U6.22 (GPIO14/TOUCH14/ADC2_CH3/FSPIWP/FSPIDQS/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)
/IO17: J3.19, U6.10 (GPIO17/U1TXD/ADC2_CH6)
/IO21: J3.20, U6.23 (GPIO21)
/IO38: J3.22, U6.31 (GPIO38/FSPIWP/SUBSPIWP)
/IO39: J3.23, U6.32 (MTCK/GPIO39/CLK_OUT3/SUBSPICS1)
/IO40: J3.24, U6.33 (MTDO/GPIO40/CLK_OUT2)
/IO41: J3.25, U6.34 (MTDI/GPIO41/CLK_OUT1)
/IO42: J3.26, U6.35 (MTMS/GPIO42)
/IO47: J3.21, U6.24 (GPIO47/SPICLK_P/SUBSPICLK_P_DIFF)
/LoRaModule/DIO2_TXEN: D1.2 (A), M1.7 (TXEN), M1.8 (DIO2), R3.1
/PowerSupply/1.22V: D3.1 (K), R12.1, U5.4 (-)
/RTS0: J3.8, U6.8 (GPIO15/U0RTS/ADC2_CH4/XTAL_32K_P)
/RxD0: J2.3, J3.4, U6.36 (U0RXD/GPIO44/CLK_OUT2)
/TxD0: J2.4, J3.2, U6.37 (U0TXD/GPIO43/CLK_OUT1)
/USB_D+: J4.A6 (D+), J4.B6 (D+), U4.1, U4.10 (NC), U6.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+)
/USB_D-: J4.A7 (D-), J4.B7 (D-), U4.2, U4.9 (NC), U6.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-)
/USB_VBUS: D4.1 (A1), J3.1, J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), JP3.2 (B)
/~ESP_RESET: J2.5, SW2.2, U3.2 (~RESET), U6.3 (EN)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, D3.2 (A), D4.2 (A2), D6.1 (K), J2.2, J3.9, J3.11, J3.13, J3.15, J3.17, J3.27, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J5.1, M1.1 (GND), M1.2 (GND), M1.3 (GND), M1.4 (GND), M1.5 (GND), M1.11 (GND), M1.12 (GND), R4.1, R6.1, R9.1, R10.1, R11.1, R13.2, R15.2, SW1.2, SW2.1, U1.3 (PGND), U1.9 (GND), U1.11 (PGND), U2.3 (PGND), U2.9 (GND), U2.11 (PGND), U3.1 (GND), U4.3 (VSS), U4.8 (VSS), U5.2 (V-), U6.1 (GND), U6.40 (GND), U6.41 (GND)
GNDRF: J1.2 (Ext), J4.S1 (SHIELD), M1.20 (RFGND), M1.22 (RFGND)
LORA_BUSY: M1.14 (BUSY), U6.16 (GPIO46)
LORA_DIO1: M1.13 (DIO1), U6.15 (GPIO3/TOUCH3/ADC1_CH2)
LORA_RST: M1.15 (~RST), U6.17 (GPIO9/TOUCH9/ADC1_CH8/FSPIHD/SUBSPIHD)
LORA_RXEN: M1.6 (RXEN), U6.26 (GPIO45)
LORA_TXACTI: R3.2, U6.25 (GPIO48/SPICLK_N/SUBSPICLK_N_DIFF)
unnamed: D1.1 (K), R10.2
unnamed: D2.1 (K), R9.2
unnamed: D5.2 (A), R17.2
unnamed: D6.2 (A), R16.2
unnamed: J1.1 (In), M1.21 (ANT)
unnamed: J4.A5 (CC1), R15.1
unnamed: J4.B5 (CC2), R13.1
unnamed: JP2.1 (A), U5.1
unnamed: JP2.2 (C), U2.6 (EN)
unnamed: C1.2, R2.1, R4.2, U1.10 (FB)
unnamed: L2.2, U1.4 (L1)
unnamed: L2.1, U1.2 (L2)
unnamed: C10.1, R8.1, U1.8 (VINA)
unnamed: C7.2, R6.2, R7.1, U2.10 (FB)
unnamed: L3.2, U2.4 (L1)
unnamed: L3.1, U2.2 (L2)
unnamed: C11.1, R5.1, U2.8 (VINA)
unnamed: R11.2, R14.1, U5.3 (+)
SPI2_CS0: M1.19 (~SS), U6.18 (GPIO10/TOUCH10/ADC1_CH9/FSPICS0/FSPIIO4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)
SPI2_MISO: M1.16 (MISO), U6.21 (GPIO13/TOUCH13/ADC2_CH2/FSPIQ/FSPIIO7/S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)
SPI2_MOSI: M1.17 (MOSI), U6.19 (GPIO11/TOUCH11/ADC2_CH0/FSPID/FSPIIO5/S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)
SPI2_SCLK: M1.18 (SCK), U6.20 (GPIO12/TOUCH12/ADC2_CH1/FSPICLK/FSPIIO6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)
VCC: C7.1, C8.1, C9.1, C12.1, C14.1, C17.1, C18.1, J2.1, J3.5, J3.7, R7.2, R16.1, R17.1, U2.1 (VOUT), U3.3 (VCC), U6.2 (3V3)
Vin: C6.1, C13.1, C15.1, C16.1, C19.1, J3.3, J5.2, JP2.3 (B), JP3.1 (A), R5.2, R8.2, R12.2, R14.2, U1.5 (VIN), U2.5 (VIN), U2.7 (PS/SYNC), U5.5 (V+)
~5V_PS: U1.7 (PS/SYNC), U6.11 (GPIO18/U1RXD/ADC2_CH7/CLK_OUT3)

## Commit log

2024-04-07 Delete dependencies.lock
    (no a relevant file)
2024-04-07 Update .gitignore (no *.lock files)
2024-04-08 c2lora_uhf.c: Fix re-enable receive mode after transmit fails
2024-04-08 Update C2LORA_core.c and c2lora_uhf.c: update free space calulation, added some few ticks to the first timeout => fixes mode 9
2024-04-10 include tx_power in NVS data stored using 'save' command
2024-04-10 Added support for Heltec WiFi LoRa 32 V3 boards
2024-04-11 Update heltec_wifi_lora_v3.h - some comments + port-power pin
2024-04-14 first quick'n'dirty OLED UI (display on a Heltec WiFi LoRa 32)
2024-04-14 show (LOG) exact tuned frequency during SX126x init
2024-04-14 Update TFT.c comment
2024-04-16 updated "is with header" logic, don't assume faulty packets having header if there are still a part of a stream
2024-04-16 cleanup build system, minor changes, cosmetics
2024-04-16 in the moment there is a shortage of peripheral interrupts: I²C on breadboard is disabled (needed 4 touch) + no TFT AND OLED together (not designed for this)
2024-04-16 using "pixel" instead of "color" on monochrome displays. Cleanup.
2024-04-16 change notify logic (use last index and altered bitmask)
2024-04-16 removed common function duplicates
2024-04-16 TFT select (SPI device) and Wait4Completion added
2024-04-16 Breadboard first simple UI (very basic)
2024-04-16 some HW dependent conditional compiling
2024-04-17 Update board layout (same schematic, only bugfixes + layout imporvements)
2024-04-17 some renaming and splitting files for adding codecs later
2024-04-17 Added OLED reset GPIO pin setup for Heltec LoRa 32 display
2024-04-17 Better naming, wifi enable cmd
2024-04-21 add a display timeout to the OLED UI, README better + link to wiki
2024-04-22 Update board definition Heltec WiFi LoRa V3 (free LED IO)
2024-04-22 Adding LED_Pin init
2024-04-22 Adding dependencies for UI Kconfig
2024-04-22 LocalRecorder improvements (not jet finished)
2024-04-22 Update C2LORA_header: alter recipient function added
2024-04-22 Update C2LORA_core.c - less status infos,alter packet length in advance with start
2024-04-22 A lot of rework, adding an ECHO function (a reception with recipient "ECHO" will be transmitted back)
2024-04-23 Check_Call() bugfix short callsigns
2024-04-23 set and get txpower bugfix
2024-04-23 Update T-Deck target, still not functional (missing SPI management for UI)
2024-05-03 Adjusted RX dBm (LNA modules) values for UI
